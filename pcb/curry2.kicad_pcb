# Repository etf-lth/rasdaq

File README.md:

# Rasdaq: Raspberry Pi Data Acquisition

Rasdaq is a 8-channel 16-bit high-speed ADC solution using the Raspberry Pi, with current measurement adapters.
Rasdaq was developed by ETF (The Student’s Association for Applied Electronics at the Faculty of Engineering (LTH), Lund University, Sweden) for
academic research in power efficiency of graphic accelerators (GPUs).

An illustrated introduction is available here: http://etf.nu/projects/rasdaq

User manual and schematics are available in `doc/`.

## KiCad design pcb/curry2.kicad_pcb

Parts:
C101, C102, C117, C118, C119, C120, C122, C125: 10µF
C103, C106, C109, C110, C113: 0.1µF
C104, C105, C107, C108, C111, C112, C114, C115: 4.7µF
C116: 1µF
C121: 0.47µF
C123, C124: 22pF
CON101: AVR-ISP-6
D101, D102: LED
IC101: ATMEGA88-A; TQFP32
L101, L102, L103, L104, L105: INDUCTOR
P1, P2: CONN_4
P101: CONN_2
P102: CONN_4X2
R1: 0R?
R101, R103, R104, R105: R
R102: 4k7
SW101, SW102: SPST
U101: RASPI
U102: BQ32000
U103: ADS8568
X102: CRYSTAL

Connections:
+5V: L102.1, L103.1, P1.4, P101.1, U101.2 (5V), U101.4 (5V); also elsewhere on the board
/BUSY/INT: IC101.2 ((PCINT20/XCK/T0)PD4), U101.3 (GIPO2), U103.35 (BUSY/INT)
/CONVA: IC101.12 ((PCINT0/CLKO/ICP1)PB0), P102.7, U103.37 (CONVST_A)
/CONVB: IC101.13 ((PCINT1/OC1A)PB1), P102.5, U103.38 (CONVST_B)
/CONVC: IC101.14 ((PCINT2/OC1B/~SS~)PB2), P102.3, U103.39 (CONVST_C)
/CONVD: CON101.4, IC101.15 ((PCINT3/OC2/MOSI)PB3), P102.1, U103.40 (CONVST_D)
/CS: U101.31 (GPIO30), U103.13 (CS/FS)
/HW: CON101.1, IC101.16 ((PCINT4/MISO)PB4), SW101.2, U103.41 (HW/SW)
/PAR: IC101.26 ((PCINT11/ADC3)PC3), U103.8 (PAR_/SER)
/RANGE: IC101.1 ((PCINT19/OC2B/INT1)PD3), U103.34 (RANGE/XCLK)
/RD: U101.32 (GPIO31), U103.12 (RD)
/RES: IC101.24 ((PCINT9/ADC1)PC1), U103.10 (RESET)
/RST: CON101.5, IC101.29 ((PCINT14/~RESET~)PC6), R103.2
/SCL: IC101.28 ((PCINT14/SCL/ADC5)PC5), P1.2, R102.1, U101.30 (GPIO29), U102.6 (SCL)
/SDA: IC101.27 ((PCINT12/SDA/ADC4)PC4), P1.3, R101.2, U101.29 (GPIO28), U102.5 (SDA)
/SLEEP: IC101.9 ((PCINT21/OC0B/T1)PD5), U103.36 (ASLEEP)
/STD: IC101.25 ((PCINT10/ADC2)PC2), U103.9 (STDBY)
/WR: IC101.23 ((PCINT8/ADC0)PC0), U103.11 (REFN/WR)
/chAop/OUT1: U103.42 (CH_A0); also elsewhere on the board
/chAop/OUT2: U103.47 (CH_A1); also elsewhere on the board
/chBop/OUT1: U103.49 (CH_B0); also elsewhere on the board
/chBop/OUT2: U103.54 (CH_B1); also elsewhere on the board
/chCop/OUT1: U103.64 (CH_C0); also elsewhere on the board
/chCop/OUT2: U103.59 (CH_C1); also elsewhere on the board
/chDop/OUT1: U103.7 (CH_D0); also elsewhere on the board
/chDop/OUT2: U103.2 (CH_D1); also elsewhere on the board
/power/Enable: IC101.30 ((PCINT16/RXD)PD0); also elsewhere on the board
AGND: C103.2, C104.2, C105.1, C106.2, C107.2, C108.1, C109.2, C110.2, C111.2, C112.1, C113.2, C114.2, C115.1, C117.2, C118.2, C121.1, R1.2, U103.5 (AGND), U103.15 (AGND), U103.44 (AGND), U103.51 (AGND), U103.55 (REFN), U103.58 (AGND), U103.62 (AGND); also elsewhere on the board
AVDD: C103.1, C106.1, C109.1, C110.1, C113.1, C117.1, C118.1, L104.1, L105.1, U103.4 (AVDD), U103.14 (AVDD), U103.45 (AVDD), U103.52 (AVDD), U103.57 (AVDD), U103.61 (AVDD); also elsewhere on the board
DB0: U101.5 (GPIO3), U103.33 (DB0)
DB1: U101.7 (GPIO4), U103.32 (DB1)
DB2: U101.8 (GPIO14), U103.31 (DB2)
DB3: U101.10 (GPIO15), U103.30 (DB3)
DB4: U101.11 (GPIO17), U103.29 (DB4)
DB5: U101.12 (GPIO18), U103.28 (DB5)
DB6: U101.13 (GPIO27), U103.27 (DB6)
DB7: U101.15 (GPIO22), U103.26 (DB7)
DB8: U101.16 (GPIO23), U103.23 (DB8)
DB9: U101.18 (GPIO24), U103.22 (DB9)
DB10: U101.19 (GPIO10), U103.21 (DB10)
DB11: U101.21 (GPIO9), U103.20 (DB11)
DB12: U101.22 (GPIO25), U103.19 (DB12)
DB13: U101.24 (GPIO8), U103.18 (DB13)
DB14: U101.23 (GPIO11), U103.17 (DB14)
DB15: U101.26 (GPIO7), U103.16 (DB15)
DVDD: C101.1, C102.1, C116.1, CON101.2, IC101.4 (VCC), IC101.6 (VCC), IC101.18 (AVCC), L101.1, R101.1, R102.2, R103.1, U102.8 (VCC), U103.25 (DVDD)
GND: C101.2, C102.2, C116.2, C123.1, C124.1, CON101.6, IC101.3 (GND), IC101.5 (GND), IC101.21 (GND), P1.1, P2.1, P101.2 (PM), R1.1, R104.1, R105.1, SW101.1, SW102.1, U101.6 (GND), U101.9 (GND), U101.14 (GND), U101.20 (GND), U101.25 (GND), U101.33 (GND), U101.34 (GND), U102.4 (GND), U103.24 (DGND); also elsewhere on the board
HVDD: C104.1, C107.1, C111.1, C114.1, U103.48 (HVDD); also elsewhere on the board
HVSS: C105.2, C108.2, C112.2, C115.2, U103.1 (HVSS); also elsewhere on the board
unnamed: C121.2, U103.56 (REFIO)
unnamed: L101.2, U101.1 (3v3), U101.17 (3V3)
unnamed: C125.2, U103.43 (REFAP)
unnamed: C125.1, U103.46 (REFAN)
unnamed: C119.1, U103.3 (REFDN)
unnamed: C119.2, U103.6 (REFDP)
unnamed: C120.2, U103.63 (REFCP)
unnamed: C120.1, U103.60 (REFCN)
unnamed: C122.2, U103.53 (REFBN)
unnamed: C122.1, U103.50 (REFBP)
unnamed: CON101.3, IC101.17 ((PCINT5/SCK)PB5), SW102.2
unnamed: P2.3, U102.1 (OSCI)
unnamed: P2.4, U102.2 (OSCO)
unnamed: P2.2, U102.3 (VBAT)
unnamed: D101.2 (K), R105.2
unnamed: D102.2 (K), R104.2
unnamed: D101.1 (A), IC101.32 ((PCINT18/INT0)PD2)
unnamed: D102.1 (A), IC101.31 ((PCINT17/TXD)PD1)
unnamed: IC101.10 ((PCINT22/OC0A/AIN0)PD6), P102.2, P102.4, P102.6, P102.8
unnamed: L102.2, L103.2, L104.2, L105.2
unnamed: C124.2, IC101.7 ((PCINT6/XTAL1/TOSC1)PB6), X102.1
unnamed: C123.2, IC101.8 ((PCINT7/XTAL2/TOSC2)PB7), X102.2

Parts:
C201, C202, C203, C204, C205, C206, C207, C208: C
L201, L202: INDUCTOR
RV201, RV202: POT
U201: LT3032
U202: IA0515S_

Connections:
+5V: U202.1 (IN+); also elsewhere on the board
/power/Enable: U201.10 (SHDN), U201.12 (SHDNP); also elsewhere on the board
AGND: C201.2, C202.2, C203.2, C204.2, C207.1, C208.1, RV201.3, RV202.3, U201.4 (GND), U201.5 (GND), U201.15 (GND), U202.4 (OUTGND); also elsewhere on the board
GND: U202.2 (IN-); also elsewhere on the board
HVDD: C201.1, L201.1; also elsewhere on the board
HVSS: C202.1, L202.1; also elsewhere on the board
unnamed: C205.1, U201.3 (BYPP)
unnamed: C207.2, U201.6 (INN), U201.9 (INN), U201.16 (INN), U202.3 (VOUT-)
unnamed: C208.2, U201.14 (INP), U202.5 (VOUT+)
unnamed: RV202.2, U201.8 (ADJN)
unnamed: RV201.2, U201.2 (ADJP)
unnamed: C206.1, U201.11 (BYPN)
unnamed: C204.1, C206.2, L202.2, RV202.1, U201.7 (OUTN)
unnamed: C203.1, C205.2, L201.2, RV201.1, U201.1 (OUTP)

Parts:
C301, C306: NI
C302, C303: 100nF
C304, C307: 39pF
C305, C308: 2200pF
K301, K302: CONN_3
P301: CONN_5X2
R301, R303, R308, R310: NI
R302, R305, R309: 0R
R304, R306, R311, R313: 1K
R307, R314: 10R
R312: 0
U301: TL082

Connections:
/chAop/OUT1: C308.2, R314.2; also elsewhere on the board
/chAop/OUT2: C305.2, R307.2; also elsewhere on the board
AGND: C301.2, C302.1, C303.1, C305.1, C306.2, C308.1, P301.2, P301.4, P301.6, P301.8, P301.10, R302.1, R303.1, R309.1, R310.1; also elsewhere on the board
AVDD: P301.9; also elsewhere on the board
HVDD: C302.2, P301.7, U301.8 (V+); also elsewhere on the board
HVSS: C303.2, P301.5, U301.4 (V-); also elsewhere on the board
unnamed: C307.2, K302.1, R313.2, U301.7
unnamed: R312.2, U301.5 (+)
unnamed: C307.1, R310.2, R311.2, R313.1, U301.6 (-)
unnamed: K301.2 (PM), R307.1
unnamed: R305.2, U301.3 (+)
unnamed: C306.1, R308.1, R309.2, R312.1
unnamed: C301.1, R301.1, R302.2, R305.1
unnamed: K302.3, P301.3, R308.2, R311.1
unnamed: K302.2 (PM), R314.1
unnamed: C304.2, K301.1, R306.2, U301.1
unnamed: C304.1, R303.2, R304.2, R306.1, U301.2 (-)
unnamed: K301.3, P301.1, R301.2, R304.1

Parts of its further copies:
C401, C406, C501, C506, C601, C606: NI
C402, C403, C502, C503, C602, C603: 100nF
C404, C407, C504, C507, C604, C607: 39pF
C405, C408, C505, C508, C605, C608: 2200pF
K401, K402, K501, K502, K601, K602: CONN_3
P401, P501, P601: CONN_5X2
R401, R403, R408, R410, R501, R503, R508, R510, R601, R603, R608, R610: NI
R402, R405, R409, R502, R505, R509, R602, R605, R609: 0R
R404, R406, R411, R413, R504, R506, R511, R513, R604, R606, R611, R613: 1K
R407, R414, R507, R514, R607, R614: 10R
R412, R512, R612: 0
U401, U501, U601: TL082

Connections of its further copies:
/chBop/OUT1: C408.2, R414.2; also elsewhere on the board
/chBop/OUT2: C405.2, R407.2; also elsewhere on the board
/chCop/OUT1: C508.2, R514.2; also elsewhere on the board
/chCop/OUT2: C505.2, R507.2; also elsewhere on the board
/chDop/OUT1: C608.2, R614.2; also elsewhere on the board
/chDop/OUT2: C605.2, R607.2; also elsewhere on the board
AGND: C401.2, C402.1, C403.1, C405.1, C406.2, C408.1, C501.2, C502.1, C503.1, C505.1, C506.2, C508.1, C601.2, C602.1, C603.1, C605.1, C606.2, C608.1, P401.2, P401.4, P401.6, P401.8, P401.10, P501.2, P501.4, P501.6, P501.8, P501.10, P601.2, P601.4, P601.6, P601.8, P601.10, R402.1, R403.1, R409.1, R410.1, R502.1, R503.1, R509.1, R510.1, R602.1, R603.1, R609.1, R610.1; also elsewhere on the board
AVDD: P401.9, P501.9, P601.9; also elsewhere on the board
HVDD: C402.2, C502.2, C602.2, P401.7, P501.7, P601.7, U401.8 (V+), U501.8 (V+), U601.8 (V+); also elsewhere on the board
HVSS: C403.2, C503.2, C603.2, P401.5, P501.5, P601.5, U401.4 (V-), U501.4 (V-), U601.4 (V-); also elsewhere on the board
unnamed: K401.2 (PM), R407.1
unnamed: K401.3, P401.1, R401.2, R404.1
unnamed: K402.2 (PM), R414.1
unnamed: C401.1, R401.1, R402.2, R405.1
unnamed: R405.2, U401.3 (+)
unnamed: K402.3, P401.3, R408.2, R411.1
unnamed: C404.2, K401.1, R406.2, U401.1
unnamed: C404.1, R403.2, R404.2, R406.1, U401.2 (-)
unnamed: R412.2, U401.5 (+)
unnamed: C407.1, R410.2, R411.2, R413.1, U401.6 (-)
unnamed: C406.1, R408.1, R409.2, R412.1
unnamed: C407.2, K402.1, R413.2, U401.7
unnamed: K501.2 (PM), R507.1
unnamed: K501.3, P501.1, R501.2, R504.1
unnamed: C501.1, R501.1, R502.2, R505.1
unnamed: K502.2 (PM), R514.1
unnamed: R505.2, U501.3 (+)
unnamed: K502.3, P501.3, R508.2, R511.1
unnamed: C504.2, K501.1, R506.2, U501.1
unnamed: C504.1, R503.2, R504.2, R506.1, U501.2 (-)
unnamed: R512.2, U501.5 (+)
unnamed: C507.1, R510.2, R511.2, R513.1, U501.6 (-)
unnamed: C506.1, R508.1, R509.2, R512.1
unnamed: C507.2, K502.1, R513.2, U501.7
unnamed: K601.2 (PM), R607.1
unnamed: K601.3, P601.1, R601.2, R604.1
unnamed: K602.2 (PM), R614.1
unnamed: C601.1, R601.1, R602.2, R605.1
unnamed: R605.2, U601.3 (+)
unnamed: K602.3, P601.3, R608.2, R611.1
unnamed: C604.2, K601.1, R606.2, U601.1
unnamed: C604.1, R603.2, R604.2, R606.1, U601.2 (-)
unnamed: R612.2, U601.5 (+)
unnamed: C607.1, R610.2, R611.2, R613.1, U601.6 (-)
unnamed: C606.1, R608.1, R609.2, R612.1
unnamed: C607.2, K602.1, R613.2, U601.7

Board: 2 copper layers, 168 parts (51 on the bottom side), 127 nets.

## KiCad design pcb/highcurrent.kicad_pcb

Parts:
C1, C2: Cf
C3, C5: 100n
C4, C6: 1n
C7: massor
JP1: JUMPER3
P1: CH_A
P2: CH_B
P3: RADAQ
U1, U2: ACS710; MODULE

Connections:
/OUT_A: P3.1, U1.12 (VIOUT)
/OUT_B: JP1.1, U2.12 (VIOUT)
/REF_A: C4.1, JP1.3, U1.10 (VZCR)
/REF_B: C6.1, U2.10 (VZCR)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, P3.2, P3.4, P3.6, P3.8, P3.10, U1.9 (GND), U1.15 (VOC), U1.16 (FAULT_EN), U2.9 (GND), U2.15 (VOC), U2.16 (FAULT_EN)
unnamed: C1.1, U1.11 (FILTER)
unnamed: JP1.2, P3.3
unnamed: C2.1, U2.11 (FILTER)
unnamed: P1.2 (PM), U1.5 (IP-), U1.6 (IP-), U1.7 (IP-), U1.8 (IP-)
unnamed: P1.1, U1.1 (IP+), U1.2 (IP+), U1.3 (IP+), U1.4 (IP+)
unnamed: P2.1, U2.1 (IP+), U2.2 (IP+), U2.3 (IP+), U2.4 (IP+)
unnamed: P2.2 (PM), U2.5 (IP-), U2.6 (IP-), U2.7 (IP-), U2.8 (IP-)
VCC: C3.1, C5.1, C7.1, P3.9, U1.14 (VCC), U2.14 (VCC)

Notes on the sheet:
Cf = 100pF för BW = 120kHz

Board: 2 copper layers, 51.4 x 28.6 mm, 17 parts (0 on the bottom side), 13 nets.

Other parts of the board:
1PIN, 1PIN#2, 1PIN#3, 1PIN#4: P***; 1pin

## KiCad design pcbina/inaboard.kicad_pcb

Board: 2 copper layers, 30.0 x 52.0 mm, 19 parts (12 on the bottom side), 12 nets.

Parts:
1PIN, 1PIN#2, 1PIN#3, 1PIN#4: P***; 1pin
C1, C2, C3, C4: C; SM0805
P1, P3: CONN_2; bornier2
P2: CONN_5X2; PIN_ARRAY_5x2
R1, R3, R4, R6: R; SM0805
R2, R5: R; SM2512
U1, U2: INA193; SOT23-5

Connections:
GND: C2.1, C3.1, P2.2, P2.4, P2.6, P2.8, P2.10, U1.2, U2.2
unnamed: C2.2, C3.2, P2.7, U1.5, U2.5
unnamed: C4.1, R4.2, U2.3
unnamed: P2.3, U1.1
unnamed: P2.1, U2.1
unnamed: P3.1, R4.1, R5.2
unnamed: P1.1, R1.1, R2.2
unnamed: P1.2, R2.1, R3.1
unnamed: P3.2, R5.1, R6.1
unnamed: C1.2, R3.2, U1.4
unnamed: C1.1, R1.2, U1.3
unnamed: C4.2, R6.2, U2.4

## Commit log

2013-03-26 Schematic almost done
2013-03-27 almost done rtc placed
2013-03-28 fixed all pcb components
2013-03-28 all op is done blaj
2013-04-02 almost done
2013-04-02 städa lite
2013-04-02 fuffens
2013-04-02 almost done pre merger
2013-04-02 pcb done just needs currentsensors
2013-04-02 added highcurrent
2013-04-02 added ina board
2013-04-04 final release pre order
2013-04-04 ina commit
2013-04-04 moved outputs
2013-04-04 moved outputfiles
2013-04-04 gerber
2013-04-04 rotatted
2013-04-04 added 10x10
2013-04-04 shrunk ina
2013-04-04 added high_current gerber
2013-04-04 added panel
2013-04-20 fw wip
2013-04-21 radaq kernel module
2013-04-23 adc write and read
2013-04-23 adc reset level fix
2013-04-28 bakfyllekod...
2013-05-11 this seems to successfully raise a fiq
2013-05-12 fiq+irq working?!
2013-05-12 8ch@100k?
2013-05-12 semaphore bug fix
2013-05-15 gpio read delay
2013-05-21 maxbufsz and more
2015-05-31 organized stuff
2015-05-31 added user guide
2015-05-31 added pdf schematics
